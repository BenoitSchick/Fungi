<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ad5940-examples-master\ad5940-examples-master\examples\AD5940_Impedance\ADICUP3029\AD5940_Impedance.ewp</path>
    </project>
    <batchBuild />
</workspace>
