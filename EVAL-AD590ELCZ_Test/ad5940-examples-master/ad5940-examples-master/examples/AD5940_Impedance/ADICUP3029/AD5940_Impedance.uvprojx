# Keil uVision project AD5940_Impedance.uvprojx, settings and files
target ADICUP3029 (6180000::V6.18::ARMCLANG)
  device: ADuCM3029 Analog Devices
  pack: AnalogDevices.ADuCM302x_DFP.3.2.0
  cpu: IRAM(0x20000000,0x04000) IRAM2(0x20040000,0x04000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ADICUP3029
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: CHIPSEL_594X,ADI_DEBUG
  c include: ..\..\;..\..\AD5940Lib
  asm define: CHIPSEL_594X
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20040000 size 0x4000
  group AD5940Lib
    ../../AD5940Lib/: ad5940.c
    ./: ADICUP3029Port.c
  group Application
    ./: main.c
    ../: AD5940Main.c Impedance.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.10.0, Device:Global Configuration 3.2.0, Device:Startup 3.2.0
